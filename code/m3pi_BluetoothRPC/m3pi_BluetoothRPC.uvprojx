# Keil uVision project m3pi_BluetoothRPC.uvprojx, settings and files
target m3pi_BluetoothRPC (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: m3pi_BluetoothRPC
  c flags: Optim=2 uC99=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 -DMBED_BUILD_TIMESTAMP=1480176530.49 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; RPCInterface; m3pi; mbed/.; mbed/LPC1768;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M3,-D__CMSIS_RTOS,-DARM_MATH_CM3,-D__MBED_CMSIS_RTOS_CM
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/LPC1768/LPC1768.sct
  group LPC1768
    mbed/LPC1768/: capi.ar cmsis_nvic.o core_cm3.h core_cm3.o LPC17xx.h mbed.ar stackheap.o startup_LPC17xx.o system_LPC17xx.h system_LPC17xx.o
  group RPCInterface
    RPCInterface/: RPCFunction.cpp RPCFunction.h RPCVariable.h SerialRPCInterface.cpp SerialRPCInterface.h
  group m3pi
    m3pi/: m3pi.cpp m3pi.h
  group m3pi_BluetoothRPC
    ./: main.cpp mbed_config.h
  group mbed
    mbed/: AnalogIn.h AnalogOut.h Base.h BusIn.h BusInOut.h BusOut.h CAN.h can_helper.h cmsis.h cmsis_nvic.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h error.h Ethernet.h FileHandle.h FileLike.h FileSystemLike.h FunctionPointer.h I2C.h I2CSlave.h InterruptIn.h LocalFileSystem.h mbed.h PeripheralNames.h PinNames.h platform.h PortIn.h PortInOut.h PortNames.h PortOut.h PwmOut.h rpc.h rtc_time.h Serial.h SerialHalfDuplex.h SPI.h SPIHalfDuplex.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h wait_api.h
